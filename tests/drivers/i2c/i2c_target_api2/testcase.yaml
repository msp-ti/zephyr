## tests/drivers/i2c/i2c_target_api2/testcase.yaml
```yaml
tests:
  drivers.i2c.api2:
    depends_on: i2c
    tags:
      - drivers
      - i2c
    filter: dt_alias_exists("gy271")
```
